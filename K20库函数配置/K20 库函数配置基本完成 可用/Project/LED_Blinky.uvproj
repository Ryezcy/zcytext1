# Keil uVision project LED_Blinky.uvproj, settings and files
target LED_Blinky (ARM-ADS)
  device: MK20DN64xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: LED_Blinky +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\CMSIS;..\Drivers;..\Startup;..\Users
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group Startup
    ../Startup/: system_MK20D5.c startup_MK20D5.s
  group Drivers
    ../Drivers/: uart.c gpio.c systick.c FTM.c exti.c pit.c spi.c i2c.c can.c wdog.c adc.c
  group Users
    ../Users/: main.c kinetis_it.c
  group Abstract
    ../: read me.txt
